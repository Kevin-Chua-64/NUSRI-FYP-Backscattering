options:
  parameters:
    author: Admin
    generate_options: no_gui
    id: Pluto_scattered_filesink
    output_language: python
    title: Pluto scattered file store
  states: {}

blocks:
- name: LO
  id: variable
  parameters:
    value: '868000000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '80'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3200000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: Pluto_Rx.bin
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: decim
    type: complex
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: int(samp_rate/2)
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Off'''
    frequency: LO
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: int(samp_rate/2)
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Off'''
    frequency: LO
    gain1: '''manual'''
    manual_gain1: '15'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.2
  states: {}

connections:
- [analog_sig_source_x_0, '0', iio_pluto_sink_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_file_sink_0, '0']
- [iio_pluto_source_0, '0', blocks_keep_one_in_n_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0

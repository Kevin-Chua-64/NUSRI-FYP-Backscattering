options:
  parameters:
    author: Admin
    generate_options: qt_gui
    id: Pluto_scattered_FSK
    output_language: python
    title: Pluto scattered FSK
  states: {}

blocks:
- name: FM_decim
  id: variable
  parameters:
    value: int(samp_rate/decim/(bit_rate))
  states: {}
- name: FM_devia
  id: variable
  parameters:
    value: '1'
  states: {}
- name: GUI_t
  id: variable
  parameters:
    value: '1'
  states: {}
- name: LO
  id: variable
  parameters:
    value: '868000000'
  states: {}
- name: bias
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: bit_rate
  id: variable
  parameters:
    value: '20'
  states: {}
- name: decim
  id: variable
  parameters:
    value: int(samp_rate/(8*freq))
  states: {}
- name: freq
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: low_pass
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 1.5*freq+1000
    gain: '1.0'
    samp_rate: samp_rate
    width: freq
    win: window.WIN_HAMMING
  states: {}
- name: postamble
  id: variable
  parameters:
    value: '[+1,+1,+1,-1,-1,-1,+1,-1,-1,+1,-1]'
  states: {}
- name: postamble_label
  id: variable_qtgui_label
  parameters:
    gui_hint: (3,1,1,1)
    label: 'Postamble: '
    type: raw
    value: postamble
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '[+1,+1,+1,+1,+1,-1,-1,+1,+1,-1,+1,-1,+1]'
  states: {}
- name: preamble_label
  id: variable_qtgui_label
  parameters:
    gui_hint: (3,0,1,1)
    label: 'Preamble: '
    type: raw
    value: preamble
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3200000'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: FM_decim
    audio_pass: 0.1*freq
    audio_stop: 2*freq
    chan_rate: samp_rate/decim
    deviation: FM_devia*freq
    gain: '1.0'
    tau: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: FSK_Demod.bin
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: float
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '1'
    sps: '1'
    symbols: preamble
    threshold: '0.9'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_corr_est_cc_0_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '1'
    sps: '1'
    symbols: postamble
    threshold: '0.9'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, down_th=-0.5, up_th=0.5, default_out=0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Threshold',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.down_th = down_th
              self.up_th = up_th
              self.default_out = default_out

          def work(self, input_items, output_items):
              for smapleIndex in range(len(input_items[0])):
                  if input_items[0][smapleIndex] <= self.down_th:
                      output_items[0][smapleIndex] = -1.0
                  elif input_items[0][smapleIndex] >= self.up_th:
                      output_items[0][smapleIndex] = 1.0
                  else:
                      output_items[0][smapleIndex] = self.default_out

              return len(output_items[0])
    default_out: '0.0'
    down_th: '-0.5'
    up_th: '0.5'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Extract data',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32, np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

              self.to_start = 0  # count to start
              self.to_end = 0  # count to end
              '''state
                  1 when estimated preamble, prepare to start
                  2 when estimated postamble, prepare to stop
                  3 when info data is transmitting
                  0 otherwise'''
              self.state = 0

          def work(self, input_items, output_items):
              for smapleIndex in range(len(input_items[0])):
                  # detect tag
                  tags = self.get_tags_in_window(0, smapleIndex, smapleIndex+1)  # get the tags
                  for tag in tags:
                      key = pmt.to_python(tag.key)
                      if key != 'corr_est':  # only to find tag "corr_est"
                          continue
                      else:
                          value = pmt.to_python(tag.value)
                          if (round(value)==169) and (self.state==0):  # preamble
                              self.state = 1
                              self.to_start = 13
                          elif (round(value)==121) and (self.state==3):  # postamble
                              self.state = 2
                              self.to_end = 11
                          break
                  
                  # do
                  output_items[1][smapleIndex] = None
                  if self.state == 3:  # transmitting
                      output_items[1][smapleIndex] = input_items[0][smapleIndex]  # data to port 1
                  elif self.state == 1:  # prepare to start
                      self.to_start -= 1
                  elif self.state == 2:  # prepare to stop
                      self.to_end -= 1
                  
                  # state update
                  if (self.state==1) and (self.to_start==0):  # data start at next sample
                      self.state = 3
                  elif (self.state==2) and (self.to_end==0):  # end and stop
                      self.state = 0

              output_items[0][:] = input_items[0]  # copy all samples to output port 0
              return len(output_items[0])
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: decim
    samp_rate: samp_rate
    taps: low_pass
    type: ccc
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: int(samp_rate/2)
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Off'''
    frequency: LO-bias
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: int(samp_rate/2)
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Off'''
    frequency: LO
    gain1: '''manual'''
    manual_gain1: '20'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.2
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    grid: 'True'
    name: Rx
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decim
    fc: '0'
    fftsize: '32768'
    grid: 'True'
    name: Filtered Rx
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0,1,4)
    name: Rx
    size: int(GUI_t*samp_rate)
    srate: samp_rate
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (1,0,1,4)
    name: Filtered Rx
    size: int(GUI_t*samp_rate/decim)
    srate: samp_rate/decim
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (2,0,1,4)
    name: FM Demod
    size: int(GUI_t*samp_rate/decim/FM_decim)
    srate: samp_rate/decim/FM_decim
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (4,0,1,4)
    name: Tagged
    size: int(GUI_t*samp_rate/decim/FM_decim)
    srate: samp_rate/decim/FM_decim
    type: float
    ymax: '3'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_2_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (5,0,1,4)
    name: Data
    size: int(GUI_t*samp_rate/decim/FM_decim)
    srate: samp_rate/decim/FM_decim
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: demod
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: demod
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', epy_block_1, '0']
- [analog_fm_demod_cf_0, '0', qtgui_time_sink_x_2, '0']
- [analog_sig_source_x_0, '0', iio_pluto_sink_0, '0']
- [blocks_complex_to_float_0, '0', epy_block_2, '0']
- [blocks_float_to_complex_0, '0', digital_corr_est_cc_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_tag_gate_0, '0', qtgui_time_sink_x_2_0_0, '0']
- [digital_corr_est_cc_0, '0', digital_corr_est_cc_0_0, '0']
- [digital_corr_est_cc_0_0, '0', blocks_complex_to_float_0, '0']
- [epy_block_1, '0', blocks_file_sink_0, '0']
- [epy_block_1, '0', virtual_sink_1, '0']
- [epy_block_2, '0', qtgui_time_sink_x_2_0, '0']
- [epy_block_2, '1', blocks_tag_gate_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_fm_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [iio_pluto_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_1, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
